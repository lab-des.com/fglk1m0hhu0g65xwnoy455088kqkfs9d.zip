Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-26T13:36:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 26 13:36:33 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{E5D74A2D-9270-4965-8508-A1B30881DC80}\ifc * Database version: 5507 * Database creation date: Mon Aug 26 13:36:33 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 26 13:36:33 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 26 13:36:33 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Eames plastic side chair DSX, Furniture_Chairs&Stools&Benches_Vitra_Eames-Plastic-Chair_DSX:Eames plastic side chair DSX:383696
In: Level 1
Type - Material: Glide black, 01 chrome, 23 ice grey
Type - Construction(Type) - SeatCushionVisibility: no; SeatType: Eames_plastic_DSX_simplechair+cushion
Type - Dimensions(Type) - NominalDepth: 550 mm; NominalHeight: 830 mm; NominalLength: 465 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs&Stools&Benches_Vitra_Eames-Plastic-Chair_DSX; ConvergoRefNr: 0089-1908-0001-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: A four-legged tubular steel base and the organically shaped Side Chair shell are the defining components of the visually understated DSX (Dining Height Side Chair X-Base). The seat shell comes in various colours and upholstery options while the base is available in a chrome-plated or powder-coated version, the latter of which can be used in gardens or on terraces.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 26/08/2019
Type - Identity Data(Type) - Collection: Eames plastic side chair; Cost: 0; Description: A four-legged tubular steel base and the organically shaped Side Chair shell are the defining components of the visually understated DSX (Dining Height Side Chair X-Base). The seat shell comes in various colours and upholstery options while the base is available in a chrome-plated or powder-coated version, the latter of which can be used in gardens or on terraces.; Designer: Charles & Ray Eames; Manufacturer: Vitra; Model: Eames plastic side chair DSX; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-gb/_storage/asset/2814503/storage/master/download/Factbook%20Eames%20Shell%20Chairs-EN.pdf; Type Name: Eames plastic side chair DSX; URL: https://www.vitra.com/de-ch/living/product/details/eames-plastic-side-chair-dsx
Type - Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs&Stools&Benches_Vitra_Eames-Plastic-Chair_DSX; Features: Optional seat cushion or full upholstery.; Finish: Seat shell: dyed-through polypropylene. All models are available with a seat cushion (screwed to the seat shell) or full upholstery. The fully upholstered version has moulded polyurethane foam padding covered in fabric, attached to the shell with a welted edge. Different shell and upholstery colours and various bases provide a multitude of possible combinations. Options: the Eames Plastic Chair is available as a visitor chair, dining chair, rocking chair, swivel chair or in stacking versions and with ganging brackets for row seating. Beam-mounted shells are suited for use in waiting areas. Base: non-stacking four-legged tubular steel base. The powder-coated version is suitable for outdoor use. (DSX = Dining Height Side Chair X-Base) Note: special additives retard the fading of colours due to UV radiation. However, if the chair is exposed to sunlight for prolonged periods, the colour may change over time. We recommend limited exposure to sunlight.; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: Eames-Plastic-Chair_DSX; ReplacementCost: n/a; Shape: Sculptured; Size: 465x550x830 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.09826 m2; Volume: 0.212291 m3
Materials and Finishes - ChairMainMaterial: 23 ice grey; ChairQuaternaryMaterial: Glide black; ChairSecondaryMaterial: Textile hopsak nero 66; ChairTertiaryMaterial: 01 chrome
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs&Stools&Benches_Vitra_Eames-Plastic-Chair_DSX: Eames plastic side chair DSX; Family and Type: Furniture_Chairs&Stools&Benches_Vitra_Eames-Plastic-Chair_DSX: Eames plastic side chair DSX; InstallationDate: n/a; Material: Polypropylene, wood & aluminium; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs&Stools&Benches_Vitra_Eames-Plastic-Chair_DSX: Eames plastic side chair DSX; Type Id: Furniture_Chairs&Stools&Benches_Vitra_Eames-Plastic-Chair_DSX: Eames plastic side chair DSX; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
